# EAGLE board proxmark3 (EAGLE 4.11), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via)
+2V5  (via drill 0.4)
  Top 0.203: C30.1 46.1,1.65 46.22,1.77 IC1.14 46.23,4.57 46.35,4.7 v46.35,5.33 | C31.1 56.01,9.4 55.92,9.31 IC1.33 52.74,9.31 52.32,8.89 51.31,8.89 50.8,9.4 50.8,9.53 50.8,9.65 51.69,10.54 52.45,10.54 52.68,10.31 IC1.35 | 38.91,8.81 IC1.94 36.15,8.81 35.81,9.14 35.77,9.11 35.56,9.11 35.56,9.02 | 38.91,8.81 39.12,9.02 39.12,9.53 | 39.12,9.53 38.99,9.65 | IC1.92 38.83,9.81 39.12,9.53 | 44.7,9.02 44.7,10.92 42.93,12.7 | 42.93,12.7 42.8,12.83 | IC1.85 42.31,13.31 42.93,12.7 | IC1.61 46.72,18.18 v46.99,17.91 | 48.77,9.53 48.77,12.45 49.78,13.46 | 49.78,13.46 49.91,13.59 | IC1.42 50.13,13.81 49.78,13.46 | 38.91,8.81 39.29,8.81 39.37,8.89 | 35.56,9.02 35.56,8.89 | C29.1 35.56,9.02
  Top 0.61: IC12.6 33.02,40.26 33.15,40.13 IC12.5 35.56,40.26 36.2,39.62 40.64,39.62 41.66,40.64 44.07,40.64 44.17,40.74 | 44.17,40.74 44.2,40.77 | 44.17,40.74 C33.1 46.33,40.74 v46.35,40.77 | 39.12,9.02 44.7,9.02 45.21,9.02 | 45.21,9.02 v45.34,9.02 | 50.8,9.53 48.77,9.53 46.61,9.53 46.1,9.02 45.21,9.02
  Bottom 0.203: 46.35,17.91 v46.99,17.91
  Bottom 0.61: 46.35,9.02 v46.35,5.33 | 46.35,9.02 46.35,17.91 v46.35,40.77 | v45.34,9.02 46.35,9.02
+3V3  (via drill 0.4)
  Top 0.203: IC2.45 67.46,8.79 v66.67,8 66.59,7.91 C25.1 66.59,5.25 66.04,4.7 62.23,4.7 | 69.67,17.48 IC2.59 | v69.6,17.4 69.67,17.48 | IC2.58 71.21,17.36 71.25,17.4 71.17,17.48 69.67,17.48 | v69.72,22.23 IC2.1 68.96,20.07 68.45,19.56 67.18,19.56 65.96,20.78 IC2.7 65.96,24.69 66.17,24.89 | C26.1 67.22,25.95 66.17,24.89 | 66.17,24.89 66.04,24.77 | SV3.1 74.93,46.1 73.66,44.83 73.66,41.91 69.72,37.97 v69.72,38.1 | R7.2 63.16,38.14 63.12,38.1 | 67.18,38.1 67.18,37.97 67.31,37.85 R43.2 | 62.23,4.7 62.1,4.7 | IC2.18 61.13,19.48 61.34,19.68 v61.34,20.57 | 58.79,6.74 58.91,6.74 58.91,6.62 58.99,6.54 | 62.23,4.7 60.83,4.7 58.99,6.54 | 58.99,6.54 58.93,6.48 IC7.2
  Top 0.406: 23.11,46.86 23.24,46.99 | 23.11,46.86 C27.1 23.11,46.74 23.24,46.86 25.4,46.86 26.42,47.88 SV5.6 | 23.11,46.86 23.04,46.79 22.4,46.79 21.21,45.59 21.21,45.09 20.95,44.83 | 20.95,44.83 20.88,44.76 | IC3.5 20.62,44.5 20.95,44.83
  Top 0.61: SV5.6 30.35,46.74 v31.62,45.47 | v61.34,38.1 63.12,38.1 67.18,38.1 v69.72,38.1
  Route15 0.61: v31.62,45.47 35.43,45.47 36.96,43.94 49.28,43.94 51.31,41.91 v61.72,41.91
  Bottom 0.203: 67.31,8.38 66.93,8.38 66.67,8.13 v66.67,8 | v69.6,17.4 69.6,17.02 69.72,16.89
  Bottom 0.61: v61.72,41.91 61.34,41.53 v61.34,38.1 v61.34,20.57 | v69.72,38.1 v69.72,22.23 69.72,16.89 69.72,9.02 69.09,8.38 67.31,8.38
+3V3-FPGA  (via drill 0.4)
  Top 0.203: IC13.5 36.42,24.8 36.45,24.77 36.47,24.79 C34.1 36.47,22.33 37.72,21.08 37.72,17.78 IC1.76 43.63,17.81 | 43.63,17.81 45.12,17.81 | 45.12,17.81 45.72,18.41 IC1.63 | 49.95,17.81 48.55,17.81 47.5,16.76 46.1,16.76 45.09,17.78 45.12,17.81 | 37.72,5.84 | 37.72,5.84 IC1.100 | C28.1 37.76,5.8 37.72,5.84 | 49.95,17.81 49.95,16.72 v50.04,16.64 | v51.05,5.84 51.94,5.84 | 51.94,5.84 52.07,5.84 | 51.94,5.84 51.97,5.81 IC1.26 58.58,5.81 60.2,4.19 67.31,4.19 C47.1 67.31,3.81 68.45,3.81 68.83,3.43 68.83,2.03 69.34,1.52 73.66,1.52 73.91,1.78 73.91,2.16 73.87,2.2 IC4.5 | IC1.37 51.06,11.31 v50.93,11.18 | 43.63,17.81 43.63,16.82 v43.94,16.51 | IC1.12 45.22,4.82 44.83,5.21 43.18,5.21 v42.42,5.97 42.29,5.84 37.72,5.84 | IC1.90 43.67,10.81 v43.94,10.54 | 49.95,17.81 49.95,18.33 50.42,18.8 53.09,18.8 53.72,18.16 IC1.50 54.9,17.81 55.12,18.03 55.12,19.05 55.08,19.09 | 55.08,19.09 54.99,19.18 | 55.08,19.09 C32.1 55.28,19.09 55.88,19.68 55.88,20.07 56.01,20.19 56.01,22.23 55.75,22.48 R59.2 55.84,22.19
  Bottom 0.203: v50.93,11.18 50.16,11.18 50.04,11.05 | v43.94,10.54 43.81,10.54 43.94,10.41
  Bottom 0.406: v50.04,16.64 50.04,11.05 50.04,10.92 49.91,10.79 49.91,6.99 v51.05,5.84 | v43.94,16.51 43.94,10.41 43.94,7.49 v42.42,5.97
ADC1
  Top 0.203: IC8.3 45.37,21.95 45.72,21.59 | 45.72,21.59 45.85,21.46 | IC1.62 46.22,21.09 45.72,21.59
ADC2
  Top 0.203: IC8.4 46.02,22.18 47.22,20.98 IC1.60
ADC3
  Top 0.203: IC8.5 46.66,22.55 47.5,21.72 | 47.5,21.72 47.62,21.59 | IC1.58 48.22,21 47.5,21.72
ADC4
  Top 0.203: IC8.6 47.31,22.66 48.51,21.46 | 48.51,21.46 48.64,21.34 | IC1.57 48.72,21.26 48.51,21.46
ADC5
  Top 0.203: IC8.7 47.97,22.65 48.9,21.72 | 48.9,21.72 49.02,21.59 | IC1.56 49.22,21.39 48.9,21.72
ADC6
  Top 0.203: IC8.8 48.62,22.76 49.53,21.84 | 49.53,21.84 49.66,21.72 | IC1.55 49.72,21.65 49.53,21.84
ADC7
  Top 0.203: IC8.9 49.27,22.74 50.04,21.97 | 50.04,21.97 50.16,21.84 | IC1.54 50.22,21.79 50.04,21.97
ADC8
  Top 0.203: IC8.10 49.91,22.98 50.29,22.61 | 50.29,22.61 50.67,22.23 | IC1.53 50.72,22.18 50.29,22.61
ADC_CLK  (via drill 0.4)
  Top 0.203: IC8.12 51.54,24.23 51.56,24.26 52.07,23.75 v52.07,23.11 | IC1.46 51.63,15.81 v51.18,16.26
  Bottom 0.203: v52.07,23.11 51.56,22.61 51.56,21.59 51.69,21.46 51.69,17.53 51.18,17.02 v51.18,16.26
ADC_IN  (via drill 0.4)
  Top 0.203: 33.35,24.05 33.4,24 | 33.35,24.05 IC11.9 33.4,24.13 | 33.35,24.05 33.27,24.13 IC11.10 32.7,24.07 32.77,24 32.64,23.88 32.64,22.99 31.4,21.75 IC11.3 IC11.2 30.73,18.03 | 33.4,24.13 | 33.4,24.13 33.4,28.07 v33.27,28.19 | TP1.1 41.91,28.96 42.29,28.57 v43.56,28.57 43.56,28.45 43.69,28.57 47.12,28.57 47.31,28.77 IC8.19
  Route15 0.203: v33.27,28.19 43.18,28.19 v43.56,28.57
ADC_NOE  (via drill 0.4)
  Top 0.203: R47.2 42.71,25.36 43.84,24.23 IC8.1 44.04,24.23 43.94,24.13 44.07,24 44.07,23.24 v43.81,22.99 43.69,22.86 | IC1.47 52.78,16.31 v52.2,16.89
  Route15 0.203: 43.69,22.99 43.81,22.86 v43.81,22.99 44.96,24.13 v53.47,24.13
  Bottom 0.203: v52.2,16.89 52.2,21.84 53.47,23.11 v53.47,24.13
ADCDR_HI
  Top 0.203: IC11.11 32.05,23.16 31.75,22.86 30.23,22.86 29.59,22.23 29.59,21.46 29.46,21.34 29.46,14.99 29.43,14.95 IC6.8 30.23,14.86 30.99,14.1 R18.2 32.3,14.19 32.38,14.1 32.47,14.19 C17.2
ADCDR_LO  (via drill 0.4)
  Top 0.203: R14.2 34.25,1.82 34.29,1.78 34.33,1.82 C13.2 35.81,1.78 36.96,2.92 36.96,4.06 36.58,4.45 33.78,4.45 | 33.78,4.45 33.53,4.45 | v29.34,10.67 29.43,10.58 IC6.7 29.43,8.04 29.84,7.62 30.23,7.62 33.4,4.45 33.78,4.45 | IC11.4 32,18.03 v32,16.38
  Bottom 0.203: v29.34,10.67 29.34,13.21 32,15.88 v32,16.38
AMPL_HI  (via drill 0.4)
  Top 0.203: IC2.4 67.46,24.49 v67.18,24.77 | v23.37,25.4 R42.2 21.8,22.06 21.72,21.97 R41.2
  Route15 0.203: v23.37,25.4 23.37,25.91 24.13,26.67 31.5,26.67 31.88,26.29 65.66,26.29 v67.18,24.77
AMPL_LO  (via drill 0.4)
  Top 0.203: R31.2 26.12,5.12 26.29,4.95 | R31.2 R30.2 | IC2.3 67.94,22.21 67.94,21.08 v67.31,20.45 | 26.29,4.95 26.29,5.04 R31.2 | 26.29,4.95 26.42,4.83 26.42,4.45 v26.54,4.32
  Route15 0.203: v65.66,8.26 64.52,7.11 56.26,7.11 51.69,2.54 37.34,2.54 35.69,4.19 26.67,4.19 v26.54,4.32
  Bottom 0.203: v65.66,8.26 66.67,9.27 66.67,11.81 66.42,12.06 66.42,14.48 67.44,15.49 67.44,20.32 v67.31,20.45
ANT_HI  (via drill 0.4)
  Top 0.203: SV2.4 6.88,22.08 7.24,21.72 10.16,21.72 | 10.16,21.72 10.41,21.46 10.41,20.19 | 10.41,20.19 TP3.1 | 10.41,20.19 10.29,20.07 9.14,20.07 v8.26,19.18 | 10.16,21.72 10.16,23.24 | 10.16,23.24 10.16,23.37 C36.1 10.2,23.28 | 10.2,23.28 C35.1 | 10.16,23.24 10.2,23.28 | v7.24,4.7 7.24,2.03 7.49,2.29 RLY1.8
  Bottom 0.203: v8.26,19.18 8.26,5.71 v7.24,4.7
ANT_LO  (via drill 0.4)
  Top 0.203: SV2.2 8.4,24.15 9.14,24.89 9.14,25.91 | 9.14,25.91 9.14,26.29 9.65,26.8 C39.1 10.29,26.8 | 10.29,26.8 10.41,26.67 | C20.1 10.2,26.89 10.29,26.8 | 9.14,25.91 8.13,25.91 v7.87,26.16 | TP2.1 2.54,15.75 2.67,15.88 | 2.67,15.88 2.67,17.14 v3.17,17.65 | 2.67,15.88 2.67,14.35 3.05,13.97 6.48,13.97 7.37,13.08 7.37,11.94 | 7.3,11.75 7.37,11.68 | 7.3,11.75 7.11,11.94 | RLY1.3 7.49,11.81 7.37,11.94 | 7.3,11.75 7.24,11.68 | 7.37,11.94 7.37,11.81 7.3,11.75
  Bottom 0.203: v7.87,26.16 7.87,23.24 3.3,18.67 3.3,17.78 v3.17,17.65
ARM_TCK  (via drill 0.4)
  Top 0.203: SV3.9 64.52,46.61 63.5,45.59 63.5,40.77 64.9,39.37 R7.1 | IC2.53 67.69,14.47 v66.42,15.75
  Bottom 0.203: SV3.9 65.28,46.61 66.04,45.85 66.04,38.35 65.66,37.97 65.66,35.94 65.79,35.81 65.91,35.69 65.91,17.27 66.04,17.14 66.04,16.13 v66.42,15.75
ARM_TDI  (via drill 0.4)
  Top 0.203: IC2.33 61.46,10.17 61.47,10.16 v60.2,10.16
  Bottom 0.203: SV3.5 69.85,47.88 68.71,49.02 59.69,49.02 58.42,47.75 58.42,21.59 58.8,21.21 58.8,19.68 58.42,19.3 58.42,11.94 v60.2,10.16
ARM_TDO  (via drill 0.4)
  Top 0.203: v68.71,12.45 69.34,12.45 69.37,12.47 IC2.49
  Bottom 0.203: SV3.13 59.69,47.24 60.96,48.51 68.2,48.51 68.58,48.13 68.58,12.57 v68.71,12.45
ARM_TMS  (via drill 0.4)
  Top 0.203: SV3.7 67.31,46.35 66.04,45.09 66.04,43.31 v67.18,42.16 | IC2.51 67.55,13.47 v67.18,13.84
  Bottom 0.203: v67.18,42.16 68.07,41.27 68.07,14.35 67.56,13.84 v67.18,13.84
BUTTON_A
  Top 0.203: SW1.B 69.05,32.04 68.71,32.38 67.44,32.38 67.31,32.51 R43.1 | IC2.15 61.96,23.64 60.83,24.77 60.83,30.35 61.09,30.61 66.04,30.61 67.31,31.88 R43.1 | R43.1 67.31,32.64
CROSS_HI  (via drill 0.4)
  Top 0.203: v32.77,10.67 R44.1 | IC5.6 17.72,25.85 17.91,26.04 19.05,26.04 v19.3,25.78
  Route15 0.203: v15.62,10.79 26.92,10.79 27.69,11.56 31.62,11.56 32.51,10.67 v32.77,10.67
  Bottom 0.203: v15.62,10.79 17.78,12.95 17.78,14.1 17.14,14.73 17.14,16.38 17.78,17.02 17.78,25.02 18.54,25.78 v19.3,25.78
CROSS_LO  (via drill 0.4)
  Top 0.203: 34.04,12.28 34.04,12.19 | 34.04,12.28 R39.1 | v34.04,13.72 34.04,12.28 | IC5.7 17.07,25.85 16.89,26.04 15.75,26.04 v15.49,25.78
  Route15 0.203: v15.88,12.45 17.02,11.3 26.54,11.3 28.96,13.72 v34.04,13.72
  Bottom 0.203: v15.88,12.45 16.64,13.21 16.64,24.64 v15.49,25.78
FPGA_CCLK  (via drill 0.4)
  Top 0.203: IC2.41 65.46,12.14 64.77,12.83 v64.77,13.72 | IC1.75 39.72,21.11 v39.5,21.34
  Route15 0.203: v39.5,21.34 39.5,18.16 39.88,17.78 41.02,17.78 41.66,18.41 43.81,18.41 45.21,17.02 47.62,17.02 49.02,18.41 58.67,18.41 59.56,19.3 61.34,19.3 61.72,18.92 v64.64,18.92
  Bottom 0.203: v64.64,18.92 64.77,18.8 v64.77,13.72
FPGA_DIN  (via drill 0.4)
  Top 0.203: IC2.42 65.96,12.78 v65.66,13.08 | IC1.73 40.72,18.59 v40.77,18.54
  Route15 0.203: v40.77,18.54 40.77,18.41 41.27,18.92 58.42,18.92 59.31,19.81 v65.15,19.81
  Bottom 0.203: v65.66,13.08 65.66,14.61 65.41,14.86 65.41,19.56 v65.15,19.81
FPGA_DONE  (via drill 0.4)
  Top 0.203: IC1.49 52.79,17.31 52.45,17.65 v50.67,17.65 | v64.01,16.76 64.01,12.7 63.46,12.15 IC2.37
  Route15 0.203: v50.67,17.65 59.94,17.65 60.96,16.64 62.61,16.64 62.99,17.02 63.75,17.02 v64.01,16.76
FPGA_DOUT  (via drill 0.4)
  Top 0.203: IC1.74 40.22,21.04 v40.64,21.46 | 72.64,13.84 72.52,13.97 | 72.64,13.84 72.77,13.72 v73.03,13.72 | IC2.52 72.51,13.97 72.64,13.84
  Route15 0.203: v41.78,38.35 47.37,38.35 49.02,40.01 72.01,40.01 v75.56,36.45
  Bottom 0.203: v40.64,21.46 40.64,22.48 39.75,23.37 39.75,32.26 41.02,33.53 42.04,33.53 43.43,34.92 43.43,36.7 v41.78,38.35 | v75.56,36.45 75.56,33.15 74.93,32.51 74.93,25.91 75.56,25.27 75.56,14.22 75.18,13.84 73.15,13.84 v73.03,13.72
FPGA_NINIT  (via drill 0.4)
  Top 0.203: IC2.36 62.96,13.3 63.25,13.59 v63.25,14.1 | IC1.52 51.22,21.63 51.69,22.1 52.2,22.1 52.83,22.73 | 52.83,22.73 52.83,23.5 52.58,23.75 52.58,24.89 51.31,26.16 v51.31,28.7 | R59.1 53.09,22.48 52.83,22.73
  Route15 0.203: v63.25,14.1 64.01,14.86 68.33,14.86 68.58,15.11 77.6,15.11 v77.85,15.37 | v77.85,26.67 77.72,26.67 77.6,26.8 61.21,26.8 58.67,29.34 51.94,29.34 v51.31,28.7
  Bottom 0.203: v77.85,15.37 77.85,18.03 78.49,18.67 78.49,24.89 77.85,25.53 v77.85,26.67
FPGA_NPROGRAM  (via drill 0.4)
  Top 0.203: IC1.51 53.47,19.81 v53.72,19.81 | IC2.38 63.96,8.59 63.37,8 v63.5,8
  Bottom 0.203: v53.72,19.81 53.59,19.81 53.47,19.68 53.47,8 54.86,6.6 62.1,6.6 v63.5,8
FPGA_ON  (via drill 0.4)
  Top 0.203: IC12.8 29.34,38.48 v30.86,36.96 | v41.78,34.92 41.53,34.92 40.51,33.91 R23.2 40.6,32.35 | 40.6,32.35 39.24,30.99 39.24,29.46 39.27,29.44 IC13.3 39.27,29.49 | 40.6,32.35 41.62,32.35 v41.66,32.38 | IC2.26 59.18,15.49 62.23,15.49 62.74,14.99 v62.61,14.99
  Route15 0.203: v30.86,36.96 33.78,36.96 34.04,36.7 39.12,36.7 39.62,37.21 40.26,37.21 41.15,36.32 41.15,35.56 v41.78,34.92 | v41.66,32.38 60.07,32.38 v60.33,32.13
  Bottom 0.203: 62.74,14.99 v62.61,14.99 62.36,15.24 62.36,18.29 | 62.36,18.29 62.36,18.41 | v60.33,32.13 60.33,20.45 61.09,19.68 61.85,19.68 62.36,19.18 62.36,18.29
FPGA_TCK  (via drill 0.4)
  Top 0.203: v34.67,7.11 34.67,6.86 34.92,6.6 | 34.92,6.6 35.05,6.48 | IC1.99 35.22,6.31 34.92,6.6
  Bottom 0.203: SV5.4 35.43,7.87 v34.67,7.11
FPGA_TDI  (via drill 0.4)
  Top 0.203: v36.32,16.26 36.58,16.26 | v36.32,16.26 36.2,16.26 | IC1.79 36.38,16.31 v36.32,16.26
  Bottom 0.203: SV5.2 39.12,46.48 36.96,46.48 36.45,45.97 36.45,18.16 37.21,17.4 37.21,16.76 36.7,16.26 v36.32,16.26
FPGA_TDO  (via drill 0.4)
  Top 0.203: 36.45,17.27 v36.32,17.27 36.36,17.31 IC1.77
  Bottom 0.203: SV5.3 37.21,47.88 35.94,46.61 35.94,17.65 v36.32,17.27
FPGA_TMS  (via drill 0.4)
  Top 0.203: IC1.2 40.22,4.87 39.88,5.21 39.12,5.21 38.48,4.57 v38.48,4.32
  Bottom 0.203: SV5.1 41.15,45.97 37.59,45.97 37.08,45.47 37.08,18.41 37.72,17.78 37.72,6.6 38.48,5.84 v38.48,4.32
GND  (via drill 0.4, 2 pad 4)
  Top 0.203: 78.23,4.19 78.36,4.32 78.4,4.28 C2.2 78.53,4.28 78.61,4.19 78.35,3.93 IC4.3 76.07,3.81 75.44,3.81 74.8,3.17 72.64,3.17 71.88,2.41 C3.2 | IC14.4 23.92,31.03 23.24,30.35 23.24,27.3 23.33,27.39 C22.2 | IC1.24 51.22,5.04 51.18,5.08 50.29,5.08 49.53,5.84 49.53,6.35 49.91,6.73 51.82,6.73 51.9,6.81 IC1.28 53.72,6.86 IC1.29 52.12,7.31 52.07,7.37 51.69,7.37 v51.56,7.49 | C31.2 55.92,11.01 55.12,11.81 IC1.38 | IC1.64 45.22,20.82 45.09,20.95 | 45.09,20.95 44.96,21.08 | IC8.2 44.72,23.12 44.58,22.99 44.58,21.46 45.09,20.95 | C30.2 44.32,1.65 44.72,2.05 IC1.11 | C28.2 39.37,1.91 39.72,2.25 IC1.1 | IC1.89 39.23,11.31 39.68,11.76 | IC1.78 39.07,16.81 39.12,16.76 | IC2.46 67.96,7.99 68.33,7.62 68.33,6.86 68.2,6.73 C25.2 | C11.2 21.25,6.77 21.21,6.73 21.25,6.69 R11.1 | IC5.2 17.07,22.92 17.27,23.11 18.37,23.11 | 18.37,22.9 IC5.4 18.37,21.38 18.41,21.34 | 18.37,23.62 IC5.5 | C23.2 13.55,22.14 12.7,22.99 12.06,22.99 11.9,23.15 C36.2 11.9,24.98 11.94,25.02 C35.2 11.9,26.71 11.81,26.8 C39.2 11.94,26.8 11.9,26.84 C20.2 | IC9.10 18.04,35.7 18.16,35.81 18.16,36.83 | IC10.10 24.9,33.65 25.4,33.15 26.67,33.15 27.3,33.78 v27.3,34.29 | IC2.60 72.58,17.98 73.53,17.02 v73.66,17.02 73.79,17.02 | 40.89,24.13 v40.64,24.13 40.36,24.13 C34.2 | IC13.2 40.27,28.46 40.64,28.83 v40.64,31.11 | v43.05,31.37 43.79,30.63 IC8.24 44.06,30.48 44.07,30.48 44.07,29.46 44.32,29.21 45.97,29.21 46.02,29.25 IC8.21 46.08,30.63 46.1,30.61 46.13,30.63 IC8.20 46.66,31.55 46.86,31.75 47.62,31.75 47.88,32 47.88,32.64 C19.2 | 24.77,20.19 v24.64,20.32 24.6,20.36 R42.1 | 18.37,23.62 v19.3,23.62 | R10.1 30.86,1.91 v29.97,1.02
  Top 0.203: IC11.7 34,17.11 33.53,16.64 v33.02,16.64 | 39.68,11.76 39.75,11.83 | 77.6,19.18 v77.72,19.18 78.23,19.18 | IC2.2 68.46,27.17 68.07,27.56 67.56,27.56 67.44,27.69 67.4,27.65 C26.2 | 16.55,16.42 C15.2 | R15.1 16.55,16.42 | 16.55,16.42 16.51,16.38 | 18.16,16.38 18.2,16.42 R15.1 | 39.68,11.76 39.75,11.68 v39.75,11.81 | IC12.3 v31.88,37.97 | v55.24,16 55.24,16.26 54.69,16.81 IC1.48 | 18.37,23.11 18.37,21.76 18.41,21.72 18.41,21.71 18.41,21.34 | 18.37,23.11 18.37,23.62 | v39.88,40.64 39.37,40.64 39.24,40.77 39.24,41.66 38.52,42.37 | 38.52,42.37 38.48,42.42 | C38.- 38.52,42.37 | 18.41,21.34 | v10.16,41.91 11.05,41.91 11.43,42.29 11.81,42.29 12.45,42.93 13.46,42.93 13.59,42.8 C46.2 | C27.2 23.11,43.69 22.98,43.55 IC3.2 | 78.23,19.18 78.61,19.56 79.38,19.56 C7.1 | 78.23,19.18 78.74,18.67 79.12,18.67 79.38,18.41 C6.1 | IC2.17 59.21,20.67 56.9,22.99 v57.02,22.99 56.64,23.37 55.24,23.37 54.99,23.11 54.99,21.08 55.12,20.95 C32.2 | 17.78,3.3 v17.78,3.43 17.91,3.43 19,2.34 D11.1 | R31.1 24.42,5.17 25.65,3.94 v25.53,3.94 | R15.1 18.5,16.42 18.67,16.26 v18.67,15.37 18.54,15.24 18.54,14.1 17.53,13.08 D10.1
  Route2 0.203: v29.97,1.02 29.97,1.78 29.84,1.91
  other vias: 18.8,37.08 11.94,31.88 24.26,30.23 15.11,6.73 20.57,8 25.15,12.45 27.81,2.54 42.16,16.76 33.27,7.49 67.31,29.08 39.37,33.02 7.49,15.75 69.09,5.46 73.66,5.59 62.74,5.46 43.05,1.78 48.13,5.46 56.39,12.06 10.54,46.35 27.18,49.15 22.61,45.21 1.91,45.59 4.7,45.47 4.45,42.55 4.32,23.62 7.87,28.07 7.11,20.95 7.24,18.29 11.05,9.91 10.79,4.45 15.37,8.89 32,7.49 33.02,6.35 30.73,16.26 28.7,19.05 32.13,27.69 39.37,8 66.04,1.52 74.55,24.51 73.66,29.08 74.04,31.75 73.53,36.07 56.77,33.78 60.33,37.34 66.55,36.96 47.62,13.08 45.21,13.34 47.75,10.79 21.84,25.02 23.5,37.85 26.04,37.85 33.15,37.85 2.67,44.58 5.71,7.75 55.88,3.3 58.93,3.3 57.4,4.83 57.4,1.78 57.4,3.3 26.67,44.7 29.72,44.7 28.19,43.18 28.19,46.23 28.19,44.7 48.01,27.81 39.37,49.91 27.3,50.04 57.15,48.64 73.79,49.02 77.98,43.81 78.23,34.92 79.88,34.92 80.01,22.99 80.26,12.57 79.63,9.02 48.39,1.78 55.12,31.5 51.82,33.66 34.16,32.26 29.27,45.78 29.27,43.63 27.12,43.63 27.12,45.78 58.48,2.22 58.48,4.38 56.33,4.38 56.33,2.22 14.35,21.08 4.32,44.07 5.33,43.81
  pour Route2 (isolate 0.508): 0.64,50.67 0.64,0.64 80.64,0.64 80.64,50.67
  pour Top (isolate 0.508): 0.64,50.67 0.64,0.64 80.64,0.64 80.64,50.67
  pour Bottom (isolate 0.508): 0.64,50.67 0.64,0.64 80.64,0.64 80.64,50.67
LED_A  (via drill 0.4)
  Top 0.203: IC2.48 70.93,10.22 v71.12,10.41 | 56.22,25.31 56.13,25.4 | R24.1 56.22,25.31 | v56.26,24.26 56.26,25.27 56.22,25.31
  Route15 0.203: v70.74,24 65.41,24 64.26,22.86 60.07,22.86 58.93,24 56.52,24 v56.26,24.26
  Bottom 0.203: v71.12,10.41 71.12,23.62 v70.74,24
LED_B  (via drill 0.4)
  Top 0.203: IC2.31 61.62,12.97 v62.1,13.46 | R25.1 58.67,25.27 59.69,25.27 59.82,25.4 59.82,30.99 59.31,31.5 59.31,34.04 v59.56,34.29
  Route15 0.203: v62.1,13.46 62.87,13.46 64.64,11.68 72.77,11.68 v73.03,11.94 | v71.37,34.8 60.07,34.8 v59.56,34.29
  Bottom 0.203: v73.03,11.94 72.14,11.94 71.75,12.32 71.75,34.42 v71.37,34.8
LED_C  (via drill 0.4)
  Top 0.203: IC2.30 57.8,13.47 57.53,13.21 57.53,12.19 58.29,11.43 58.29,10.54 v58.8,10.03 | v52.45,27.81 52.45,26.16 53.09,25.53 53.59,25.53 53.85,25.27 R26.1
  Route15 0.203: v58.8,10.03 58.8,10.41 59.56,11.18 61.85,11.18 62.36,10.67 69.47,10.67 70.48,9.65 72.39,9.65 v73.15,8.89 | v71.75,38.73 70.99,39.5 53.34,39.5 v52.58,38.73
  Bottom 0.203: v73.15,8.89 73.66,8.89 74.55,9.78 74.55,11.68 73.28,12.95 72.64,12.95 72.26,13.34 72.26,38.23 v71.75,38.73 | v52.58,38.73 52.58,27.94 v52.45,27.81
LED_D  (via drill 0.4)
  Top 0.203: IC2.44 66.96,12.22 v67.31,12.57 | v62.36,34.04 62.48,34.16 R55.1 63.92,34.25 | 63.92,34.25 63.88,34.29 | TP8.1 64.14,34.04 63.92,34.25
  Route15 0.203: v67.31,12.57 69.34,14.61 76.71,14.61 77.85,13.46 79.63,13.46 80.01,13.84 v80.01,15.37 | v78.11,33.66 62.74,33.66 v62.36,34.04
  Bottom 0.203: v80.01,15.37 80.01,16.76 78.99,17.78 78.99,25.53 79.38,25.91 79.38,32.38 v78.11,33.66
MISO  (via drill 0.4)
  Top 0.203: IC1.40 51.7,12.81 v51.44,13.08 | 60.96,14.61 60.71,14.86 | IC2.27 60.59,14.97 60.96,14.61 | v61.21,14.35 60.96,14.61
  Route15 0.203: v51.44,13.08 51.44,14.35 51.82,14.73 58.93,14.73 59.31,14.35 v61.21,14.35
MOSI  (via drill 0.4)
  Top 0.203: IC1.43 55.28,14.31 v55.63,13.97 | 56.52,16.89 v55.75,16.89 56.64,16.89 57.23,17.48 IC2.22
  Bottom 0.203: v55.75,16.89 55.75,16.64 56.13,16.26 56.13,14.48 v55.63,13.97
MUXSEL_HIPKD  (via drill 0.4)
  Top 0.203: IC2.13 62.96,21.05 v62.48,20.57 | v29.72,25.53 29.84,25.53 31.11,26.8 31.62,26.8 32.13,26.29 32.13,25.4 31.88,25.15 31.62,25.15 31.4,24.92 IC11.12
  Route15 0.203: v29.72,25.53 30.61,24.64 30.61,20.7 31.75,19.56 33.53,19.56 35.05,21.08 36.96,21.08 38.1,22.23 41.66,22.23 42.67,21.21 60.2,21.21 60.71,21.72 62.23,21.72 62.48,21.46 v62.48,20.57 62.61,20.57
MUXSEL_HIRAW  (via drill 0.4)
  Top 0.203: IC11.6 33.35,20.12 v33.02,20.45 | 63.96,22.3 IC2.11 63.96,20.88 v64.26,20.57
  Route15 0.203: 63.37,21.46 63.12,21.72 | 63.37,21.46 v64.26,20.57 | v33.02,20.45 33.02,20.57 34.04,21.59 36.83,21.59 37.97,22.73 41.91,22.73 42.93,21.72 59.94,21.72 60.58,22.35 62.48,22.35 63.37,21.46
MUXSEL_LOPKD  (via drill 0.4)
  Top 0.203: IC11.5 32.7,19.24 32.13,19.8 v32.13,21.21 | IC2.16 61.46,22.6 61.47,22.61 v59.18,22.61
  Route15 0.203: v59.18,22.61 57.91,22.61 57.53,22.23 43.05,22.23 42.04,23.24 37.72,23.24 36.58,22.1 33.02,22.1 v32.13,21.21
MUXSEL_LORAW  (via drill 0.4)
  Top 0.203: IC11.13 30.75,25.29 v31.24,25.78 | v62.36,24.38 62.48,24.26 62.48,22.48 62.46,22.46 IC2.14
  Route15 0.203: v31.24,25.78 61.21,25.78 62.36,24.64 v62.36,24.38
N$1
  Top 0.203: 11.94,44.83 11.98,44.87 U1.1 11.98,44.79 12.06,44.7
  Top 0.406: SV1.1 11.41,45.36 11.94,44.83 | 12.06,44.7 C1.1
N$2
  Top 0.203: IC2.63 72.56,19.48 73.03,19.94 73.03,22.23 | 73.03,22.35 R3.2 73.03,22.23 | 73.03,22.23 72.9,22.35 72.26,22.35 72.01,22.61 72.01,24.89 71.37,25.53 C5.2
N$3
  Top 0.203: 71.97,4.15 71.88,4.06 | 71.97,4.15 R2.1 71.88,4.19 72.14,3.93 IC4.4 | 71.97,4.15 72,4.19
N$4
  Top 0.203: XT1.A 76.33,6.99 77.22,6.1 78.23,6.1 78.36,5.97 78.4,6.01 R1.1 79.34,6.01 79.63,5.71 79.63,2.92 79.25,2.54 78.36,2.54 78.4,2.58 C2.1 | C2.1 78.45,2.58 | C2.1 78.49,2.67 78.17,2.98 IC4.2
N$5  (via drill 0.4)
  Top 0.203: XT1.B 72.77,6.99 74.55,8.76 78.11,8.76 78.49,8.38 R1.2 | XT1.B 71.25,6.86 70.48,6.1 70.48,4.45 70.23,4.19 R2.2 70.27,2.45 70.23,2.41 C3.1 | v40.51,10.03 40.23,10.31 IC1.91 36.58,10.31 36.58,9.31 IC1.93 | XT1.B 71.37,7.11 71.5,7.11 v71.5,8.89
  Route15 0.203: v40.51,10.03 41.66,8.89 43.69,8.89 44.45,8.13 47.37,8.13 48.39,9.14 51.56,9.14 51.94,8.76 54.74,8.76 54.99,9.02 64.26,9.02 64.39,9.14 66.55,9.14 66.8,8.89 v71.5,8.89
N$6
  Top 0.203: R3.1 C4.2
N$7
  Top 0.203: 76.07,16.64 75.95,16.76 XT2.B | XT2.B 74.36,18.48 IC2.61 | C6.2 79.38,16.76 79.37,16.76 XT2.B
N$8
  Top 0.203: IC2.62 73.33,18.98 75.56,21.21 75.69,21.21 76.07,21.59 XT2.A 79.3,21.66 79.38,21.59 C7.2
N$9
  Top 0.203: R8.2 64.39,6.73 64.46,6.8 IC2.39
N$10
  Top 0.203: 65.53,25.91 65.41,25.78 65.25,25.93 63.52,25.93 63.52,26.01 63.46,26.07 | 65.53,25.91 C8.1 | 65.53,25.91 65.46,25.84 IC2.8 65.46,20.64 65.66,20.45 | IC2.24 61.94,16.48 63.46,18 IC2.12 63.46,23.41 63.12,23.75 63.12,25.02 63.46,25.36 63.46,26.07 | 65.66,20.45 65.53,20.57 | IC2.54 68.84,14.97 68.07,15.75 68.07,18.54 | 65.66,20.45 67.56,18.54 68.07,18.54 | IC2.64 69.5,19.98 68.07,18.54 | 63.46,26.07 63.37,26.16 63.25,26.16 63.02,25.93 | 63.02,25.93 62.99,25.91 | 63.02,25.93 63.09,25.93 | 63.09,25.93 63.12,25.91 | C9.1 62.87,26.16 63.09,25.93
N$11
  Top 0.203: R4.2 74.84,11.14 73.79,12.19 73.79,14.73 72.54,15.97 IC2.56
N$12
  Top 0.203: R5.2 74.93,12.7 74.84,12.79 R6.1 74.84,14.31 | 74.84,14.31 74.93,14.22 | IC2.57 72.68,16.48 74.84,14.31
N$13
  Top 0.203: 62.74,6.73 R8.1 62.87,6.73 62.74,6.86 62.74,8 62.18,8.56 IC7.1
N$14
  Top 0.203: IC6.3 26.83,7.72 27.18,7.37 28.07,7.37 29.25,6.18 R9.1 30.86,4.66 R10.2
N$15
  Top 0.203: IC6.9 28.78,13.26 29.59,12.45 30.86,12.45 30.82,12.48 R18.1 | R18.1 C17.1 | R19.2 30.65,10.88 30.61,10.92 30.73,11.05 30.73,12.32 30.9,12.48 R18.1
N$16  (via drill 0.4)
  Top 0.203: v28.19,10.67 28.19,9.78 28.07,9.65 28.07,8.64 28.13,8.7 IC6.5 | v21.34,3.17 21.34,3.05 21.84,3.56 C12.2 22.73,3.56 22.64,3.47 R12.2
  Route15 0.203: v19.56,9.78 27.3,9.78 v28.19,10.67
  Bottom 0.203: v19.56,9.78 19.68,9.65 19.68,3.81 20.32,3.17 v21.34,3.17 21.46,3.17
N$17
  Top 0.203: R14.1 33.95,3.52 33.91,3.56 | R14.1 C13.1 | R14.1 34.16,3.56 34.12,3.52 R13.2 32.6,3.43 32.64,3.43 32.64,4.45 29.97,7.11 29.34,7.11 28.78,7.67 IC6.6
N$18
  Top 0.203: 21.68,16.42 C16.1 | R16.2 21.68,16.42 | 21.68,16.42 21.72,16.38
N$19
  Top 0.203: 21.32,9.27 21.32,8.65 23.11,6.86 | 21.32,9.27 D1.3 | 23.11,6.86 C11.1 22.86,6.77 22.86,5.12 | 23.11,6.86 R30.1 | 22.86,5.12 22.86,4.95 | 22.86,5.12 R11.2 22.99,5.17 22.99,5.08 23.24,4.83 23.24,4.57 24.34,3.47 | 21.32,9.27 20.45,9.27 19.68,8.51 19.68,3.68 D11.3 19.95,3.31 19.94,3.3 | 24.34,3.47 24.38,3.43 | 24.34,3.47 C12.1
N$20
  Top 0.203: C14.2 7.58,16.73 8.51,17.65 D3.3 | D3.3 10.54,17.65 | D3.3 10.41,17.65 10.41,18.09 D2.1
N$21
  Top 0.203: 18,18.12 R15.2 18.29,18.03 18.2,18.12 C15.1 16.64,18.03 15.88,18.03 15.37,17.53 15,17.53 D2.3 14.85,17.13 14.99,17.27 15.37,16.89 15.37,14.22 15.61,13.98 D10.3 | 18,18.12 R16.1 19.94,18.03 20.19,18.29 20.19,19.81 20.74,20.36 R41.1 | 18,18.12 17.91,18.03
N$22
  Top 0.203: C16.2 23.15,18.12 23.24,18.03 R37.2 R17.2 | R17.2 25.23,18.12 25.27,18.16 | R17.2 24.89,17.91 25.11,18.12 R36.2 27.6,18.12 28.07,17.65 28.07,15.11 28.19,14.99 28.13,14.92 IC6.10
N$23
  Top 0.203: R20.2 15.62,19.68 16.42,20.49 IC5.1
N$24
  Top 0.203: IC8.23 44.72,31.63 44.83,31.75 46.23,31.75 46.35,31.88 46.35,32.51 46.48,32.64 | 46.48,32.64 46.61,32.51 | 46.48,32.64 C18.1 | 46.48,32.64 44.74,34.38 R53.1 43.05,34.54 R54.2
N$25
  Top 0.203: R55.2 65.53,34.16 65.62,34.25 65.57,34.25 64.9,34.92 64.77,34.92 63.88,35.81 D9.+ 64.06,35.81
N$26
  Top 0.203: R21.2 17.53,19.68 17.72,19.88 IC5.3
N$27
  Top 0.203: R39.2 35.69,12.32 35.7,12.31 IC1.87
N$28
  Top 0.203: R26.2 D6.+
N$29
  Top 0.203: D5.+ 58.67,28.45 58.55,28.32 58.67,28.19 R25.2
N$30
  Top 0.203: R24.2 D4.+
N$31  (via drill 0.4)
  Top 0.203: R27.2 8.72,32.93 8.76,32.89 | 8.76,32.89 8.8,32.93 R45.2 10.38,32.93 | SV2.3 8.74,23.35 8.76,23.37 v9.02,23.37 | 10.38,32.93 10.29,33.02 | v11.43,32.89 10.41,32.89 10.38,32.93 | TP4.1 8.76,31.24 8.76,32.89 | 8.76,32.89 R29.2
  Bottom 0.203: v9.02,23.37 9.02,32.26 9.65,32.89 v11.43,32.89
N$32
  Top 0.203: R28.2 3.81,33.02 3.72,32.93 R46.2 | 5.46,32.89 5.59,32.77 | 5.46,32.89 R22.2 | R28.2 5.42,32.93 5.46,32.89 | SV2.1 6.88,30.08 6.22,30.73 4.19,30.73 4.06,30.86 TP5.1 3.94,30.86 3.81,30.99 R28.2
N$33  (via drill 0.4)
  Top 0.203: IC9.12 17.39,41.66 17.14,41.91 16.13,41.91 | 13.72,41.91 14.73,41.91 | 14.73,41.91 16.13,41.91 | 13.72,41.91 13.59,41.78 13.59,40.77 13.49,40.67 IC9.18 | IC9.16 14.79,41.85 14.73,41.91 | IC9.14 16.09,41.87 16.13,41.91 | R27.1 7.11,35.69 v7.24,35.69 | 13.72,41.91 12.06,41.91 11.3,41.15 v9.14,41.15
  Bottom 0.203: v7.24,35.69 7.24,39.5 8.89,41.15 v9.14,41.15
N$34
  Top 0.203: IC10.12 24.25,39.24 24,38.99 22.99,38.99 | 21.72,38.99 21.59,38.99 21.27,38.67 | 21.72,38.99 22.99,38.99 | 20.35,40.74 20.32,40.77 | 20.35,40.74 IC10.18 | IC10.16 21.65,39.06 21.72,38.99 | IC10.14 22.99,40.64 22.99,38.99 | R28.1 3.81,35.81 4.45,36.45 14.1,36.45 16,38.35 19.43,38.35 19.81,37.97 20.57,37.97 21.27,38.67 | 20.35,40.74 20.35,39.59 21.27,38.67
N$35  (via drill 0.4)
  Top 0.203: 14.1,1.52 12.19,1.52 12.19,2.29 12.32,2.41 12.57,2.16 RLY1.10 | 14.1,1.52 D7.1 | 17.27,5.84 Q1.3 15.62,5.84 v15.37,5.59 | 14.1,1.52 v14.1,2.79
  Bottom 0.203: v15.37,5.59 15.37,4.06 v14.1,2.79
N$36  (via drill 0.4)
  Top 0.203: 8.38,13.46 8.38,8 9.78,6.6 9.78,2.54 10.03,2.29 RLY1.9 | 8.38,13.46 6.86,14.99 6.1,14.99 5.97,15.11 5.88,15.03 C14.1 | 8.38,13.46 9.27,14.35 v11.18,14.35 | R21.1 19.14,19.6 19.18,19.56 19.3,19.68 v19.3,22.35
  Route15 0.203: v11.18,14.35 19.3,14.35 v19.43,14.48
  Bottom 0.203: v19.3,22.35 19.56,22.35 19.81,22.1 19.81,14.86 v19.43,14.48
N$37  (via drill 0.4)
  Top 0.203: v4.32,5.21 4.7,4.83 4.7,2.41 4.95,2.16 RLY1.7 | 31.5,30.1 v31.5,29.97 31.88,30.35 31.88,32.89 31.62,33.15 C42.1
  Route15 0.203: v1.14,30.86 1.4,31.11 30.73,31.11 31.5,30.35 v31.5,29.97
  Bottom 0.203: v4.32,5.21 1.14,8.38 v1.14,30.86
N$38
  Top 0.203: R40.2 17.65,9.4 17.91,9.14 17.91,7.87 18.09,7.7 | 18.09,7.7 18.16,7.62 | 18.09,7.7 Q1.1
N$39  (via drill 0.4)
  Top 0.203: D1.1 22.23,11.68 21.72,12.19 v21.72,12.7 | RLY1.2 10.03,9.14 v9.78,8.89 | v12.95,20.19 12.95,19.94 13.21,19.68 R20.1
  Route15 0.203: v13.72,13.34 21.08,13.34 v21.72,12.7
  Bottom 0.203: v9.78,8.89 9.78,17.02 v12.95,20.19 14.22,18.92 14.22,13.84 v13.72,13.34
N$40
  Top 0.203: R44.2 35.69,10.67 36.83,11.81 IC1.88
N$41  (via drill 0.4)
  Top 0.203: IC9.3 13.49,33.37 13.72,33.15 14.86,33.15 | 14.86,33.15 15.88,33.15 16.13,33.4 | 16.13,33.4 16.13,34.16 | 16.13,34.16 16.13,34.42 | IC9.5 14.73,34.54 14.86,34.42 14.86,33.15 | R22.1 5.46,35.56 v5.59,35.69 | v16.76,33.15 16.38,33.15 16.13,33.4 | IC9.7 16.09,34.2 16.13,34.16
  Route15 0.203: v5.59,35.69 5.59,34.04 5.97,33.66 16.26,33.66 v16.76,33.15
N$42  (via drill 0.4)
  Top 0.203: IC10.3 20.35,35.59 20.57,35.81 21.59,35.81 | 22.1,35.81 21.59,35.81 | 22.1,35.81 22.61,35.81 22.95,35.47 IC10.7 | IC10.5 21.72,34.54 21.59,34.67 21.59,35.81 | R29.1 v8.76,35.69 | v22.1,37.59 22.1,35.81
  Route15 0.203: v22.1,37.59 21.59,38.1 16,38.1 15.37,37.47 11.43,37.47 v11.05,37.85
  Bottom 0.203: v8.76,35.69 8.76,37.21 9.4,37.85 v11.05,37.85
N$43  (via drill 0.4)
  Top 0.203: R34.2 19.01,26.96 19.05,26.92 | IC14.7 20.34,29.73 20.07,29.46 20.07,27.3 | 20.07,27.3 19.81,27.05 19.18,27.05 19.05,26.92 | 19.05,26.92 C41.2 | 20.07,27.3 20.07,24.89 v21.46,23.5 | 30.1,17.91 IC11.1 30.1,19.68 v30.23,19.81
  Route15 0.203: v21.46,23.5 27.81,23.5 30.1,21.21 30.1,19.94 v30.23,19.81
N$44  (via drill 0.4)
  Top 0.203: R45.1 v10.41,35.56 | IC9.9 v17.4,36.07
  Route15 0.203: v10.41,35.56 16.89,35.56 v17.4,36.07
N$45  (via drill 0.4)
  Top 0.203: R46.1 2.16,35.56 v2.41,35.81 | v26.16,34.67 26.16,35.31 25.78,35.69 24.38,35.69 24.26,35.56 IC10.9
  Route15 0.203: v2.41,35.81 3.05,36.45 16.76,36.45 17.27,36.96 17.91,36.96 18.16,36.7 18.16,35.56 19.3,34.42 25.91,34.42 v26.16,34.67
N$46  (via drill 0.4)
  Top 0.203: C43.1 14.86,30.1 14.73,30.23 v12.57,30.23 | RLY1.4 4.95,9.78 v4.7,9.53
  Bottom 0.203: v4.7,9.53 4.7,17.27 12.57,25.15 v12.57,30.23
N$47
  Top 0.203: IC14.3 27.02,30.38 27.3,30.1 29.21,30.1 29.46,30.35 29.46,30.99 29.59,31.11 R49.2 29.46,31.11 | 29.46,31.11 29.34,30.99 | R35.2 29.84,31.5 29.46,31.11
N$48
  Top 0.203: IC8.17 48.62,31.6 49.66,32.64 C19.1 49.62,32.73 49.66,32.77 47.92,34.51 R52.1 R53.2 46.35,34.54
N$49  (via drill 0.4)
  Top 0.203: 16.38,44.76 16.38,44.7 16.38,42.8 16.58,42.6 IC3.3 | 16.88,44.76 v16.88,45.71 v16.89,45.72 | 24.34,49.19 24.26,49.28 | 24.34,49.19 R56.2 | v25.65,49.15 24.38,49.15 24.34,49.19 | 13.72,44.58 13.72,44.45 | U1.2 13.72,44.58 | 13.46,44.7 13.72,44.7 13.72,44.58
  Top 0.406: 13.68,44.62 13.72,44.58 | U1.2 13.68,44.62 | 13.68,44.62 13.34,44.96 13.34,45.09 13.08,45.34 13.08,47.12 13.34,47.37 Q2.3 16,47.37 16.55,47.92 R58.2 | 16.38,44.76 16.88,44.76 16.88,44.71 17.09,44.5 IC3.1 | 13.46,44.7 13.51,44.76 13.64,44.76 13.97,45.09 16,45.09 16.38,44.7
  Route15 0.203: v16.89,45.72 20.57,45.72 24,49.15 v25.65,49.15
N$50
  Top 0.203: 16.6,31.84 R32.1 | C43.2 16.6,31.84 | 16.6,31.84 16.64,31.88
N$51
  Top 0.203: 32.64,31.5 32.51,31.37 | R35.1 32.64,31.5 | C42.2 32.73,31.58 32.64,31.5
N$52  (via drill 0.4)
  Top 0.203: IC14.2 26.91,29.73 27.98,28.66 R33.1 28.11,28.66 28.19,28.57 28.28,28.66 C40.1 29.72,29.46 v30.1,29.84 | R51.2 29.55,33.44 29.21,33.78 28.57,33.78 28.32,34.04 28.32,35.18 v28.19,35.31
  Bottom 0.203: v28.19,35.31 28.19,30.23 28.83,29.59 29.84,29.59 v30.1,29.84
N$53
  Top 0.203: 19.05,28.7 C41.1 19.01,28.66 | 19.01,28.66 R34.1 15.84,28.66 15.75,28.57 R50.2 | 19.01,28.66 18.92,28.57 | 19.05,28.7 19.05,30.23 19.21,30.38 IC14.6 | 19.01,28.66 19.05,28.7
N$54
  Top 0.203: R32.2 18,30.14 18.03,30.1 18.07,30.14 R48.2 18.16,30.1 19.09,31.03 IC14.5
N$55
  Top 0.203: IC1.22 50.22,1.6 51.05,0.76 59.44,0.76 61.09,2.41 TP7.1
N$56
  Top 0.203: 23.24,14.86 R38.2 R37.1
NCS
  Top 0.203: IC1.44 56.56,14.81 56.9,14.48 59.18,14.48 59.19,14.47 IC2.28
NVDD_ON  (via drill 0.4)
  Top 0.203: IC2.43 66.46,13.42 66.29,13.59 66.29,14.35 65.53,15.11 65.53,17.14 66.42,18.03 v66.67,18.03 66.8,18.03 | R57.1 69.6,27.18 v70.87,28.45
  Route15 0.203: v70.87,28.45 71.5,27.81 78.74,27.81 79.25,27.3 79.25,18.92 78.87,18.54 78.23,17.91 76.58,17.91 75.95,18.54 69.09,18.54 68.58,18.03 v66.67,18.03
PCK0  (via drill 0.4)
  Top 0.203: IC1.36 54.59,10.81 55.24,10.16 56.9,10.16 v57.28,10.54 | 61.98,12.32 61.85,12.19 | v62.1,12.32 61.98,12.32 | IC2.34 61.96,12.3 61.98,12.32
  Route15 0.203: v57.28,10.54 57.28,10.92 58.29,11.94 61.72,11.94 v62.1,12.32
PFETGATE  (via drill 0.4)
  Top 0.203: v21.46,49.15 R56.1 | 69.64,28.92 69.72,28.83 | 69.64,28.92 R57.2 | v67.18,30.48 68.07,30.48 69.64,28.92 | v16.38,46.61 16.38,46.74 15.75,46.1 Q2.4
  Route15 0.203: v28.07,37.47 29.08,37.47 30.35,38.73 40.26,38.73 41.78,37.21 47.88,37.21 48.77,36.32 55.12,36.32 56.39,35.05 57.02,35.05 58.67,33.4 61.72,33.4 64.14,30.99 66.67,30.99 v67.18,30.48
  Bottom 0.203: 21.46,48.51 21.46,39.75 22.48,38.73 26.8,38.73 v28.07,37.47 | 21.46,48.51 v21.46,49.15 | v16.38,46.61 16.38,47.62 17.27,48.51 21.46,48.51
PWR_HI  (via drill 0.4)
  Top 0.203: 20.95,41.91 22.23,41.91 | 22.23,41.91 23.37,41.91 | 23.37,41.91 23.62,41.66 23.62,40.39 23.6,40.41 IC10.13 | IC10.15 22.3,41.84 22.23,41.91 | 20.95,41.91 18.29,41.91 18.03,41.66 IC9.11 17.91,40.64 | IC10.17 21,41.87 20.95,41.91 | IC1.80 39.56,15.81 v39.75,15.62 | 23.37,41.91 23.88,42.42 24.51,42.42 25.4,43.31 v25.4,44.58 | IC9.2 12.84,35.7 13.08,35.94 14.1,35.94 | 14.1,35.94 15.37,35.94 | 15.37,35.94 16.38,35.94 | 16.38,35.94 16.76,35.56 16.76,34.42 16.74,34.44 IC9.8 | IC9.6 15.44,34.6 15.37,34.67 15.37,35.94 | IC9.4 14.1,34.54 14.1,35.94 | 16.38,35.94 v16.38,37.21 | 17.91,40.64 | v18.03,39.24 18.03,40.51 17.91,40.64
  Route15 0.203: v38.61,45.09 37.21,46.48 29.97,46.48 29.34,47.12 27.05,47.12 25.4,45.47 v25.4,44.58
  Bottom 0.203: v39.75,15.62 39.75,16.51 37.59,18.67 37.59,44.07 v38.61,45.09 | v16.38,37.21 16.38,37.59 v18.03,39.24
PWR_LO  (via drill 0.4)
  Top 0.203: 23.37,33.27 23.6,33.51 IC10.8 23.6,34.65 23.62,34.67 23.62,36.2 24.9,37.47 IC10.11 | 20.95,33.27 19.94,33.27 19.68,33.53 | 22.35,33.27 20.95,33.27 | 23.37,33.27 22.35,33.27 | IC10.2 19.68,34.54 19.68,33.53 | IC10.4 20.95,34.54 20.95,33.27 | IC10.6 22.3,34.47 22.35,34.42 22.35,33.27 | IC1.81 35.11,15.31 v34.67,15.75 | v24,32.89 23.75,32.89 23.37,33.27 | IC9.17 14.14,39.2 14.35,38.99 14.61,38.99 | 14.61,38.99 15.37,38.99 | 15.37,38.99 16.51,38.99 16.76,39.24 16.76,40.64 IC9.13 | IC9.15 15.44,39.06 15.37,38.99 | v14.61,38.35 14.61,38.99 | v18.16,33.15 19.3,33.15 19.68,33.53
  Route15 0.203: v34.54,33.53 24.64,33.53 v24,32.89
  Bottom 0.203: v34.67,15.75 34.67,17.02 34.92,17.27 34.92,33.15 v34.54,33.53 | v14.61,38.35 14.61,36.7 v18.16,33.15
PWR_OE1  (via drill 0.4)
  Top 0.203: IC1.82 34.08,14.81 v33.27,15.62 | 12.32,33.02 v12.45,32.89 12.19,33.15 IC9.1
  Route15 0.203: v12.45,32.89 13.21,32.13 24.38,32.13 25.27,33.02 32.38,33.02 33.66,31.75 v33.66,30.48
  Bottom 0.203: v33.66,30.48 34.42,29.72 34.42,17.4 33.91,16.89 33.91,16.26 v33.27,15.62
PWR_OE2  (via drill 0.4)
  Top 0.203: IC1.83 40.22,14.31 v40.64,14.73 | v19.05,36.07 IC10.1
  Route15 0.203: v40.01,36.2 19.18,36.2 v19.05,36.07
  Bottom 0.203: v40.64,14.73 40.64,16.38 38.1,18.92 38.1,34.92 39.37,36.2 v40.01,36.2
PWR_OE3  (via drill 0.4)
  Top 0.203: IC1.84 41.5,13.81 v42.29,14.61 | IC9.19 12.83,40.64 12.83,39.5 v13.08,39.24
  Route15 0.203: v13.08,39.24 13.84,40.01 31.62,40.01 33.27,41.66 v40.26,41.66
  Bottom 0.203: v42.29,14.61 42.29,15.49 38.61,19.18 38.61,33.27 41.02,35.69 41.02,40.89 v40.26,41.66
PWR_OE4  (via drill 0.4)
  Top 0.203: IC1.86 41.67,12.81 v42.16,12.32 | v20.07,38.86 20.07,39.24 19.7,39.61 IC10.19
  Route15 0.203: v43.94,39.24 20.45,39.24 v20.07,38.86
  Bottom 0.203: v42.16,12.32 42.16,13.21 43.18,14.22 43.18,21.21 42.16,22.23 42.16,23.37 | 42.16,23.37 42.16,23.5 | v43.94,39.24 43.94,33.4 41.91,31.37 41.91,28.32 42.42,27.81 44.07,27.81 44.58,27.3 44.58,26.29 44.2,25.91 | 44.2,25.91 42.16,23.88 42.16,23.37 | 44.2,25.91 44.32,26.04
RAW_HI
  Top 0.203: R33.2 27.77,26.96 27.69,27.05 | R33.2 C40.2 29.63,26.96 | R33.2 28.07,26.92 26.04,28.96 IC14.1 | IC11.8 34,27.27 34.8,28.07 34.8,28.57 33.91,29.46 32.13,29.46 29.63,26.96 | 29.63,26.96 29.59,26.92
RELAY_ON  (via drill 0.4)
  Top 0.203: R40.1 17.65,11.18 18.67,12.19 v18.67,12.57 | IC2.25 63.22,15.97 v63.25,16
  Route15 0.203: v18.67,12.57 19.3,11.94 22.23,11.94 24.89,14.61 34.67,14.61 35.69,13.59 43.18,13.59 44.83,15.24 60.96,15.24 61.72,16 v63.25,16
  Bottom 0.203: v63.25,16 62.87,16
SPCK  (via drill 0.4)
  Top 0.203: IC1.39 54.73,12.31 v55.37,12.95 | IC2.21 57.46,17.98 56.9,18.54 56.9,19.18 | 56.9,19.18 56.9,19.3 | 56.9,19.18 56.9,19.68 v56.77,19.81
  Bottom 0.203: v55.37,12.95 55.88,12.95 56.64,13.72 56.64,19.68 v56.77,19.81
SSP_CLK  (via drill 0.4)
  Top 0.203: IC1.71 41.72,21.02 v41.66,21.08 | IC2.19 57.86,18.98 57.53,19.3 57.53,20.32 v57.66,20.45
  Route15 0.203: v43.69,27.05 43.81,26.92 56.77,26.92 v57.53,27.69
  Bottom 0.203: v57.53,27.69 57.53,24 57.91,23.62 57.91,20.7 v57.66,20.45 | v41.66,21.08 41.66,25.78 42.93,27.05 v43.69,27.05
SSP_DIN  (via drill 0.4)
  Top 0.203: IC1.32 54.82,8.81 55.37,8.26 v55.37,8.13 | IC2.10 64.46,23.55 v63.88,24.13
  Route15 0.203: v63.88,24.13 63.25,23.5 60.33,23.5 58.55,25.27 55.24,25.27 54.99,25.02 v54.99,24.13
  Bottom 0.203: v54.99,24.13 54.99,17.78 53.98,16.76 53.98,9.27 55.12,8.13 v55.37,8.13
SSP_DOUT  (via drill 0.4)
  Top 0.203: IC2.9 64.96,24.57 v64.64,24.89 | v52.07,9.78 52.58,9.78 52.61,9.81 IC1.34
  Route15 0.203: v54.36,38.1 55.88,36.58 61.85,36.58 62.61,37.34 64.39,37.34 64.77,36.96 v64.77,37.08
  Bottom 0.203: v54.36,38.1 54.36,35.94 53.47,35.05 53.47,28.07 54.48,27.05 54.48,25.27 54.23,25.02 54.23,21.97 52.83,20.57 52.83,17.53 52.96,17.4 52.96,10.67 v52.07,9.78 | v64.64,24.89 64.77,25.02 v64.77,37.08 64.64,37.21
SSP_FRAME  (via drill 0.4)
  Top 0.203: IC1.31 50.86,8.31 v50.8,8.26 | IC2.20 60.89,18.48 v60.96,18.54
  Route15 0.203: v50.8,8.26 54.1,8.26 55.12,7.24 55.75,7.24 56.26,7.75 57.28,7.75 v57.53,8
  Bottom 0.203: v57.53,8 59.82,8 61.21,9.4 61.21,11.94 59.69,13.46 59.69,18.03 60.07,18.41 60.83,18.41 v60.96,18.54
USB_D+  (via drill 0.4)
  Top 0.203: SV1.3 9.58,43.76 v10.41,42.93 10.41,42.8 | R5.1 76.58,12.7 76.71,12.57 v77.85,12.57 | D8.1 77.52,29.52 v77.98,29.97
  Route15 0.203: v75.44,39.75 74.68,40.51 50.8,40.51 48.77,42.55 32.64,42.55 30.61,40.51 25.27,40.51 23.24,42.55 13.84,42.55 13.46,42.16 11.18,42.16 v10.41,42.93
  Bottom 0.203: v75.44,39.75 75.44,40.64 75.95,41.15 76.71,41.15 77.34,40.51 77.34,39.75 76.96,39.37 76.96,29.97 | 76.96,29.97 76.96,13.46 v77.85,12.57 | 76.96,29.97 v77.98,29.97
USB_D-  (via drill 0.4)
  Top 0.203: SV1.2 10.05,44.56 11.43,43.18 v11.56,43.18 | R4.1 76.45,11.05 76.58,10.92 v77.98,10.92 | D8.2 75.62,29.9 v75.69,29.97
  Route15 0.203: v76.45,40.26 75.69,41.02 50.93,41.02 48.9,43.05 31.88,43.05 29.84,41.02 25.91,41.02 23.88,43.05 11.68,43.05 v11.56,43.18
  Bottom 0.203: v76.45,40.26 76.45,29.97 | 76.45,29.97 76.45,12.45 v77.98,10.92 | 76.45,29.97 v75.69,29.97
USB_PU  (via drill 0.4)
  Top 0.203: IC2.23 60.79,16.98 v61.34,17.53 | 76.45,14.35 R6.2 v78.23,14.35
  Route15 0.203: v61.34,17.53 66.17,17.53 67.69,16 77.09,16 77.47,16.38 78.49,16.38 79.12,15.75 79.12,15.24 v78.23,14.35
VDD  (via drill 0.4)
  Top 0.203: C22.1 21.63,28.16 21.21,28.57 21.21,29.08 IC14.8 | v19.05,39.24 IC10.20 | IC8.18 47.97,29.25 48.39,28.83 49.66,28.83 49.91,29.08 49.91,30.61 IC8.15 IC8.14 | IC8.14 50.65,30.63 50.67,30.61 | IC8.13 51.21,30.63 51.18,30.61 51.16,30.63 IC8.14 | IC8.14 IC8.11 | IC8.14 50.56,30.71 50.55,30.73 | 42.55,23.62 42.51,23.66 R47.1 42.55,23.53 42.55,23.5 42.42,23.5 40.77,25.15 40.77,27.05 40.31,27.51 IC13.1 | 37.85,29.97 37.85,27.94 38.23,27.56 38.99,27.56 | 39.27,27.53 39.24,27.56 38.99,27.56 | 51.98,32.22 52.07,32.13 | 51.98,32.22 C44.1 | 50.93,34.42 50.93,32.26 | 50.93,32.26 50.93,31.88 50.55,31.5 50.55,30.61 IC8.14 | 50.8,34.54 R52.2 | 51.98,32.22 50.93,32.22 50.93,32.26 | IC5.8 16.26,24.77 | IC13.1 39.19,27.51 39.12,27.43 | 38.99,27.56 38.99,27.43 39.06,27.51 IC13.1
  Top 0.406: RLY1.1 12.37,11.89 12.45,11.81 12.57,11.94 v13.84,11.94 13.84,4.95 15.37,3.43 D7.3 | IC9.20 11.56,40.64 v11.3,40.39 | v14.35,25.78 13.59,25.02 13.59,24 13.42,23.84 | 13.42,23.84 13.34,23.75 | 13.42,23.84 C23.1 13.59,23.75 14.48,23.75 15.49,24.77 16.26,24.77 | v23.5,8.26 23.88,8.26 24,8.38 C21.1 24.17,9.44 25.02,10.29 27.18,10.29 27.48,9.99 IC6.4 | C22.1 21.63,27.34 21.46,27.18 v21.46,26.42 26.04,26.42 28.7,23.75 C24.1 28.79,23.84 29.08,24.13 IC11.14 | C46.1 15.46,43.9 v15.62,44.07 | Q2.6 18.03,47.37 v17.65,46.99 17.65,49.53 17.44,49.74 16.73,49.74 16.64,49.66 R58.1 | v29.34,3.43 R9.2
  Top 0.61: 38.61,36.83 38.73,36.7 38.73,37.21 38.86,37.34 41.02,37.34 42.16,36.2 50.55,36.2 50.8,35.94 | 38.61,36.83 37.97,37.47 v34.54,37.47 34.54,35.69 34.04,35.18 IC12.4 | C37.+ 54.86,35.94 54.74,35.81 54.48,35.81 54.48,36.07 50.8,36.07 50.8,35.94 | 37.85,29.97 37.85,30.61 37.08,31.37 37.08,34.42 38.35,35.69 38.35,36.58 38.61,36.83 | 38.61,36.83 C38.+ | 50.8,35.94 50.8,34.54 50.93,34.42
  Route15 0.61: v15.62,44.07 15.88,43.81 24.51,43.81 26.29,42.04 29.46,42.04 31.24,43.81 v34.54,43.81
  Bottom 0.203: v19.05,39.24 19.05,39.12 19.18,38.99 | 14.22,25.65 v14.35,25.78
  Bottom 0.406: 14.86,44.07 v15.62,44.07 | 14.86,44.07 12.19,41.4 12.19,40.39 | 12.19,40.39 12.19,34.92 13.59,33.53 13.59,26.29 14.22,25.65 15.49,24.38 15.49,13.59 v13.84,11.94 | 12.19,40.39 v11.3,40.39 | 14.86,44.07 18.03,44.07 | 18.03,44.07 18.8,44.07 19.18,43.69 19.18,38.99 19.18,37.97 20.45,36.7 20.45,26.42 | 20.45,26.42 20.45,11.81 22.86,9.4 22.86,8.26 | 22.86,8.26 v23.5,8.26 | 20.45,26.42 v21.46,26.42 | v17.65,46.99 18.03,46.61 18.03,44.07 | 22.86,8.26 22.86,2.41 24.26,1.02 28.57,1.02 29.21,1.65 29.21,3.17 29.34,3.3 v29.34,3.43
  Bottom 0.61: v34.54,43.81 v34.54,37.47
VMID  (via drill 0.4)
  Top 0.203: 24.89,16.26 24.77,16.13 | 24.89,16.26 R17.1 24.98,16.42 25.02,16.38 | R36.1 25.06,16.42 25.02,16.38 | 25.02,16.38 24.89,16.26 | 25.02,16.38 24.64,16 24.64,13.59 24.3,13.25 R38.1 23.24,13.21 | 25.65,31.62 23.75,31.62 23.53,31.84 R48.1 | 25.65,31.62 26.8,31.62 27.05,31.37 27.81,31.37 27.85,31.33 | 32.51,1.91 32.51,2.29 | 32.51,1.91 R13.1 | 32.51,1.91 32.51,2.54 32.38,2.67 29.59,2.67 28.45,1.52 26.16,1.52 | IC6.2 IC6.1 v24.89,8.13 | 23.24,13.21 23.37,13.08 | v21.84,13.97 22.48,13.97 23.24,13.21 | R50.1 14.82,26.96 v14.48,27.3 | 27.85,31.33 R49.1 27.85,31.15 27.94,31.24 27.85,31.33 | 27.85,31.33 R51.1 | v25.65,32.26 25.65,31.62 | v26.16,21.34 C45.1 | v27.81,6.22 27.81,5.71 27.69,5.59 C10.1 | 30.73,8.26 v30.86,8.13 30.99,8.26 R19.1 | 25.78,2.92 v26.16,2.92 26.16,1.52 | R12.1 24.34,1.69 24.51,1.52 26.16,1.52
  Route15 0.203: 27.81,7.87 25.15,7.87 v24.89,8.13 | v14.48,27.3 24.38,27.3 v25.02,27.94 | 27.81,7.87 v27.81,6.22 | v30.86,8.13 28.07,8.13 27.81,7.87
  Bottom 0.203: 25.53,20.95 25.02,21.46 v25.02,27.94 25.65,28.57 v25.65,32.26 | 25.53,20.95 25.53,17.65 v21.84,13.97 24.89,10.92 v24.89,8.13 24.38,7.62 24.38,3.81 25.27,2.92 v26.16,2.92 | v26.16,21.34 25.91,21.34 25.53,20.95
(copper drawn outside any net)
  shapes: Top circle x6

## Text on the board
Top: top
Route2: route2
Route15: route15
Bottom: J. Westhues | bottom | proxmark3
tPlace: TMS | Vdd
bStop: J. Westhues | proxmark3